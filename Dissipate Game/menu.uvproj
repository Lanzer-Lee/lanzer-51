# Keil uVision project menu.uvproj, settings and files
target menu (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: lcd
  c flags: Optimize=8 SizeSpeed=1
  c include: .\source\head file
  group head file
    ./source/head file/: C8051F020.h lcd.h 1.h 2.h 3.h BUZZER.h sys.h TIMER.h delay.h KEY.h FSM.h GAME.h LED.h
  group source file
    ./source/source/: lcd.c main.c TIMER.c delay.c KEY.c FSM.c GAME.c BUZZER.c LED.c
